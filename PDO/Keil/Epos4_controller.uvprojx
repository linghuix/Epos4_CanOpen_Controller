# Keil uVision project Epos4_controller.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rct6
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xE, ARM_MATH_CM3
  c include: ..\Core\APP;..\Core\BSP;..\Core\Func;..\Core\Src;..\EPOS4;..\Middlewares\CANOpen\Cfg;..\Middlewares\CANOpen\inc;..\Middlewares\uCOS-II\Cfg-Interface;..\Middlewares\uCOS-II\Ports;..\Middlewares\uCOS-II\Source;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\Middlewares\CANOpen\inc\stm32;..\DSP_Lib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Src
    ../Core/Src/: main.c stm32f10x_it.c system_stm32f1xx.c stm32f1xx_hal_conf.h
  group Startup
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Include/: stm32f1xx.h
    ../Startup/: startup_stm32f103rctx_keil.s
  group HAL
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_wwdg.c
  group CONF
    ../Core/BSP/: BSP.c conf_can.c conf_global.c conf_gpio.c conf_Jlink.c conf_tim.c conf_usart.c prinf_debug_ITM.c BSP.h
  group FUNC
    ../Core/Func/: debug.c func_can.c func_CanOpen.c led.c FUNC.h
  group TASK
    ../Core/APP/: app.c
  group CANOpen
    ../Middlewares/CANOpen/Cfg/: dict.c
    ../Middlewares/CANOpen/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
    ../Middlewares/CANOpen/: canopen_readme.txt
  group uCOS-II
    ../Middlewares/uCOS-II/Cfg-Interface/: os_cpu_c.c
    ../Middlewares/uCOS-II/Source/: ucos_ii.c ucos_ii.h
    ../Middlewares/uCOS-II/Ports/: os_cpu_a.asm
  group EPOS4
    ../Core/Func/: func_global.c
    ../EPOS4/: canopen-interface.c gait.c nmt_control.c sdo_control.c func_epos.c conf_epos.c dict_config.c epos_bsp.h
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
